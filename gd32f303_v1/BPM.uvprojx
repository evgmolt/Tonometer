# Keil uVision project BPM.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BPM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c include: .\inc;.\lib\inc;.\lib\ili9341\inc;.\lib\img
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x100000
  group src
    ./src/: gd32f30x_it.c gd32f30x_usbd_hw.c main.c system_gd32f30x.c DataProcessing.h Display.c Display.h
    ./: DataProcessing.c
  group lib_src
    ./lib/src/: cdc_acm_core.c gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c gd32f303e_eval.c usbd_core.c usbd_enum.c usbd_lld_core.c usbd_lld_int.c usbd_pwr.c usbd_transc.c startup_gd32f30x_hd.s systick.c
  group ili9341
    ./lib/ili9341/src/: fonts.c ili9341.c ili9341_touch.c
